require recipes-devtools/gcc/gcc-${PV}.inc
require gccgo-cross.inc
LANGUAGES := "go"
PR = "r1"
