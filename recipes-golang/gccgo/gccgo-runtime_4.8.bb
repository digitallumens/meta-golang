require recipes-devtools/gcc/gcc-${PV}.inc
require gccgo-runtime.inc
LANGUAGES := "go"
PR = "r1"
