inherit cross
require golang.inc
require golang-cross.inc
require golang-${PV}.inc
