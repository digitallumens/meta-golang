require golang.inc
require golang-${PV}.inc
